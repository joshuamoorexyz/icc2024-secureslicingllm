options:
  parameters:
    generate_options: qt_gui
    id: multi_ue
    output_language: python
    title: Multi UE Flowgraph
  states: {}

blocks:
- name: gain0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.999'
    value: '0.06'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.999'
    value: '0.06'
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.999'
    value: '0.05'
  states: {}
- name: gain3
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.999'
    value: '0.04'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: gain0
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2009
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2007
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2008
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2005
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2006
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2011
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2012
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2013
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2010
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_3
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2000
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_1_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0_1_0_0, '0', zeromq_rep_sink_1_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', zeromq_rep_sink_1, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', zeromq_rep_sink_1_0_1, '0']
- [blocks_multiply_const_vxx_0_3, '0', zeromq_rep_sink_2, '0']
- [blocks_throttle_0_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_1_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0_3, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0_0_1, '0']
- [zeromq_req_source_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_1_0, '0']
- [zeromq_req_source_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_3, '0', blocks_throttle_0_0_0, '0']

metadata:
  file_format: 1
